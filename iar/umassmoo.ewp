# IAR project umassmoo.ewp, settings and files
configuration TEST_ACCEL (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Moo1.1-Debug (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 512
  General.GHeapSize2: 0
  ICC430.CCDefines: MOO_VERSION=MOO1_1
  XLINK.XclFile: lnk430f2618.xcl
configuration Moo1.2-Debug (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 512
  General.GHeapSize2: 0
  ICC430.CCDefines: MOO_VERSION=MOO1_2
  XLINK.XclFile: lnk430f2618.xcl
configuration Moo1.2.1-Debug (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 512
  General.GHeapSize2: 0
  ICC430.CCDefines: MOO_VERSION=MOO1_2_1
  XLINK.XclFile: lnk430f2618.xcl
  group (top)
    ../: board.h board_1_1.h board_1_2.h board_1_2_1.h compiler.h digital_accel_moo_interface.c digital_accel_moo_interface.h digital_accel_sensor.c digital_accel_sensor.h digital_accel_test.c flash.c flash.h int_temp_sensor.c int_temp_sensor.h moo.c moo.h mymoo.h port1_isr.asm quick_accel_sensor.c quick_accel_sensor.h rfid.c rfid.h send_to_reader.asm sensor.c sensor.h sensor_api.h sensor_read.c sessions.c sessions.h simple_sensor.c simple_sensor.h states.h temp_sensor.c temp_sensor.h timerA1_isr.asm version.h
